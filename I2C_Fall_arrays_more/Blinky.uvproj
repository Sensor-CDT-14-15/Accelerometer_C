# Keil uVision project Blinky.uvproj, settings and files
target ULink - Flash (ARM-ADS)
  device: MKL25Z64xxx4 Freescale
  cpu: IRAM(0x1FFFF800-0x1FFFFFFF) IRAM2(0x20000000-0x200017FF) IROM(0x0-0x0FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  scatter file: .\Flash\Blinky.sct
  link misc: --entry Reset_Handler
  group Startup
    ./: system_MKL25Z4.c startup_MKL25Z4.s
  group Source Files
    ./: Blinky.c uart.c MKL25z_I2C.c vector.c
target ULink - RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target ULinkPro - Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target ULinkPro - RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target CMSIS-DAP -Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target CMSIS-DAP -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target P&E Micro -Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target P&E Micro -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
